# Keil uVision project Lock_IOT.uvprojx, settings and files
target Lock_IOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Lock_IOT
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Core/Inc;                          ../Drivers/STM32F0xx_HAL_Driver/Inc;                          ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                          ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                          ../Drivers/CMSIS/Include;                          ..\BSP;                          ..\TY_SDK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group BSP
    ../BSP/: FaceReco.c motor.c systemstatus.c wtn6040.c flash_if.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c rtc.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group output
    ./Lock_IOT/: Lock_IOT.map
  group TY
    ../TY_SDK/: mcu_api.c protocol.c system.c
software components: CMSIS:CORE 4.3.0
